# Keil uVision project keil_c8t6.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: keil_c8t6 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\src;..\..\src\ccb\def;..\..\src\ccb\cmd;..\..\src\bsp;..\..\src\drv
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Lib
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_i2c.c
  group Startup
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group User
    ../../src/: main.c cmdtree.c
    ../../src/ccb/cmd/: ccb_cmd.c
    ../../src/drv/: drv_init.c drv_util.c drv_interrupt.c
    ../../src/bsp/: bsp.c stm32f10x_it.c
